# Keil uVision project PlantMetrics.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS2
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\;..\..\BSP;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\uCOS-II\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../: app.c app_cfg.h bsp_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h app_hooks.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_int.h bsp_led.c bsp_led.h bsp_sys.c bsp_sys.h cpu_bsp.c
    ../../BSP/KeilMDK/: cstartup.s
  group uC-CPU
    ../../../../../uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-II-Source
    ../../../../../uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS-II-Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group BSP DriverLib
    ../../BSP/driverlib/: adc.c can.c comp.c cpu.c eeprom.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c mpu.c pwm.c qei.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c adc.h can.h comp.h cpu.h debug.h eeprom.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h mpu.h pin_map.h pwm.h qei.h rom.h rom_map.h rtos_bindings.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
  group BSP Utils
    ../../BSP/utils/: uartstdio.c
  group ADC + Ports
    ../: Ports.c Ports.h tm4c123gh6pm.h
  group VEML7700
    ../: VEML7700.c VEML7700.h
  group SHT31D
    ../: SHT31.c SHT31.h
software components: CMSIS:CORE 5.4.0
